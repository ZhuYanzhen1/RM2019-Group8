# Keil uVision project Tempate.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F427IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tempate +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F4,USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: .\CORE;.\USER;.\HALLIB\STM32F4xx_HAL_Driver\Inc;.\SYSTEM;.\Hardware;.\App;.\DSP_LIB\Include;.\FreeRTOS;.\MPU9250\DMP;.\MPU9250
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c User.c User_Config.h
  group Top_Layer
    ./App/: Machine_Arm.c Manifold.c Mecanum_Wheel.c Tasks.c Algorithm.c
  group APP
    ./App/: PID.c oled.c PWM.c Remote.c Motor.c Odometer.c Referee_Decode.c
  group HARDWARE
    ./Hardware/: Random.c LED.c IIC2.c Key.c Beep.c Power.c Laser.c ADC.c CAN.c DAC.c STM_Flash.c TIM.c SPI.c USART.c Decrypt.c Encrypt.c
  group CORE
    ./CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f427xx.s
  group FreeRTOS
    ./FreeRTOS/: heap_4.c list.c port.c queue.c tasks.c timers.c
  group HALLIB
    ./HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group SYSTEM
    ./SYSTEM/: System_Config.c
    ./DSP_LIB/: arm_cortexM4lf_math.lib
